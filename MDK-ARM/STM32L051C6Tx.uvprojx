# Keil uVision project STM32L051C6Tx.uvprojx, settings and files
target STM32L051C6Tx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051C6 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L051C6Tx +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --C99
  c include: ../Inc;          ../Drivers/STM32L0xx_HAL_Driver/Inc;          ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;          ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c stm32l0xx_hal_msp.c rtc.c stm32l0xx_it.c tim.c main.c i2c.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_tim.c stm32l0xx_hal.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_uart.c
software components: CMSIS:CORE 4.1.0
